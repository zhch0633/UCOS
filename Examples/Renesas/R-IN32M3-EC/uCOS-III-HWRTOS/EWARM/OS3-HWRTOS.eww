<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OS3-HWRTOS.ewp</path>
  </project>
  <batchBuild/>
</workspace>


