# IAR project OS3-HWRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RIN32M3-EC Renesas RIN32M3-EC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..; ..\..\BSP; ..\..\BSP\IAR; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uCOS-III-HWRTOS\Source; ..\..\..\..\..\Software\uCOS-III-HWRTOS\Port\RIN32
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: OS3-HWRTOS.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h vectors.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c cpu_bsp.c
    ../../BSP/IAR/: cstartup.s iram.icf
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M3
    ../../../../../Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/ARM-Cortex-M3
    ../../../../../Software/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-III-HWRTOS
    ../../../../../Software/uCOS-III-HWRTOS/Source/: os.h os_core.c os_flag.c os_hwisr.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_var.c
  group uC/OS-III-HWRTOS/R-IN32M3
    ../../../../../Software/uCOS-III-HWRTOS/Port/RIN32/: os_hwrtos.h os_hwrtos_c.c os_hwrtos_reg.h os_hwrtos_s.asm
